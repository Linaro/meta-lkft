FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += "file://lkft.cfg"
