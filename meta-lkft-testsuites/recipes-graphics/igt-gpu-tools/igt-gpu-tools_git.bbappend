PACKAGECONFIG:append = " chamelium"
